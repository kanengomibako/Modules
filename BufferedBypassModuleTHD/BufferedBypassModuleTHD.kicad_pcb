# Repository kanengomibako/Modules

## KiCad design BufferedBypassModuleTHD/BufferedBypassModuleTHD.kicad_pcb

Parts:
C2, C4: 10u; my_C_D5.0mm_P2.50mm
C3: 1u; my_C_D5.0mm_P2.50mm
C5, C8: 100n; my_C_Disc_P2.50mm
C6, C7: 47n; my_C_Disc_P2.50mm
C9: 100u; my_C_D5.0mm_P2.50mm
C10: 1u; my_C_D5.0mm_P2.50mm_long
D1, D2, D3: 1N4148; my_D_P5.08mm_Horizontal
J1: IN; my_WirePad_0-8mmDrill
J2: SND; my_WirePad_0-8mmDrill
J3: RTN; my_WirePad_0-8mmDrill
J4: OUT; my_WirePad_0-8mmDrill
J5: LED; my_WirePad_0-8mmDrill
J6: VCC; my_WirePad_0-8mmDrill
J7, J8, J9: GND; my_WirePad_0-8mmDrill
Q1, Q2, Q3: 2SK2881-E; my_TO-92S_Wide
R1, R6: 1k; my_R_P7mm_Horizontal
R2, R4, R5, R9, R10, R11: 1M; my_R_P7mm_Horizontal
R3, R7, R8: 100k; my_R_P7mm_Horizontal
R12, R13: 10k; my_R_P7mm_Horizontal
SW1: SW; PinHeader_1x02_P2.54mm_Vertical
U1: TL072; DIP-8_W7.62mm_Socket
U2: TC4069UBP; DIP-14_W7.62mm_Socket

Connections:
GND: C5.2, C6.1, C7.1, C8.1, C9.2, J7.1, J8.1, J9.1, R7.2, R13.2, U1.4 (V-), U2.7 (VSS)
unnamed: C4.1, R6.1
unnamed: C5.1, R9.2, SW1.2
unnamed: C10.2, R1.1
unnamed: D1.2 (A), Q1.2 (G)
unnamed: C6.2, D1.1 (K), D3.1 (K), R10.1
unnamed: D2.2 (A), Q2.2 (G)
unnamed: C7.2, D2.1 (K), R11.1
unnamed: D3.2 (A), Q3.2 (G)
unnamed: J1.1, R1.2
unnamed: C2.2, J2.1
unnamed: C3.2, J3.1
unnamed: C4.2, J4.1, R7.1
unnamed: J5.1, U2.6, U2.12
unnamed: Q1.3 (D), Q2.3 (D), U1.6 (-), U1.7
unnamed: C2.1, Q1.1 (S), R3.1
unnamed: Q2.1 (S), Q3.1 (S), R5.1, U1.3 (+)
unnamed: C3.1, Q3.3 (D), R4.1
unnamed: R8.1, U2.9, U2.10
unnamed: R8.2, SW1.1, U2.1
unnamed: R9.1, U2.2, U2.11
unnamed: R10.2, U2.3, U2.8
unnamed: R11.2, U2.4, U2.5, U2.13
unnamed: R6.2, U1.1, U1.2 (-)
unnamed: C10.1, R2.1, U1.5 (+)
VB: C9.1, R2.2, R3.2, R4.2, R5.2, R12.1, R13.1
VCC: C8.2, J6.1, R12.2, U1.8 (V+), U2.14 (VDD)

Notes on the sheet:
Buffered Bypass Module THD
Rev.B Aug. 2025 github.com/kanengomibako

Board: 2 copper layers, 35.0 x 24.5 mm, 40 parts (24 on the bottom side), 27 nets.

## KiCad design TrueBypassRelayModuleTHD/TrueBypassRelayModuleTHD.kicad_pcb

Parts:
C1, C2, C3: 100n; my_C_Disc_P2.50mm
C4, C5: 1u; my_C_Disc_P2.50mm
D2, D3, D4: 1N4148; my_D_P5.08mm_Horizontal
J1: IN; my_WirePad_0-8mmDrill
J2: SND; my_WirePad_0-8mmDrill
J3: RTN; my_WirePad_0-8mmDrill
J4: OUT; my_WirePad_0-8mmDrill
J5: VCC; my_WirePad_0-8mmDrill
J6: GND; my_WirePad_0-8mmDrill
J7: LED; my_WirePad_0-8mmDrill
Q1, Q2: 2SC1815-GR; TO-92_Inline_Wide
R1, R4, R5: 100k; my_R_P7mm_Horizontal
R2: 1M; my_R_P7mm_Horizontal
R6, R7: 10k; my_R_P7mm_Horizontal
SW1: SW; PinHeader_1x02_P2.54mm_Vertical
U1: AZ850P2-5; EA2-5TNAG
U2: TC4069UBP; DIP-14_W7.62mm_Socket
U3: 78L05; TO-92_Inline_Wide

Connections:
+5V: C5.1, D2.1 (K), D3.1 (K), R4.1, R5.1, U1.1, U1.10, U2.14 (VDD), U3.1 (VO)
GND: C1.2, C4.2, C5.2, J6.1, Q1.1 (E), Q2.1 (E), U1.9, U2.7 (VSS), U3.2 (GND)
unnamed: C1.1, R2.2, SW1.1
unnamed: C2.1, R4.2, U2.9
unnamed: C2.2, U2.4
unnamed: C3.1, R5.2, U2.5
unnamed: D2.2 (A), Q1.2 (C), U1.5
unnamed: D3.2 (A), Q2.2 (C), U1.6
unnamed: D4.2 (A), J5.1
unnamed: C4.1, D4.1 (K), U3.3 (VI)
unnamed: J1.1, U1.2, U1.7
unnamed: J2.1, U1.8
unnamed: J3.1, U1.4
unnamed: J4.1, U1.3
unnamed: C3.2, J7.1, U2.3, U2.12
unnamed: Q1.3 (B), R6.1
unnamed: Q2.3 (B), R7.1
unnamed: R1.1, U2.10, U2.13
unnamed: R1.2, SW1.2, U2.1
unnamed: R2.1, U2.2, U2.11
unnamed: R6.2, U2.8
unnamed: R7.2, U2.6

Notes on the sheet:
Rev.A July 2025 github.com/kanengomibako
RESET
(Using R.G. Keen Latching Relay Driver)
True Bypass Relay Module THD
SET

Board: 4 copper layers, 24.5 x 24.5 mm, 27 parts (19 on the bottom side), 22 nets.

## KiCad design EasyTester/EasyTester_RevE.kicad_pcb

File EasyTester/README.md:

# Easy Tester

<br>簡易的な電圧計兼抵抗計です。作業机に常駐させておき、使いたいときにすぐ使えるというコンセプトとなっています。電源ボタンやオート電源オフ機能はありません。

### 使用方法

USB Type-Cコネクターに電源（4.5 ～ 20V）を接続します。電圧測定と抵抗測定は自動的に判別されます。

- 直流電圧測定

  COM端子を測定対象の電圧が低い側に、V・Ω端子を電圧が高い側に接続します。

  ※ 交流電圧、負電圧を測定することはできません。

- 抵抗測定

  COM端子とV・Ω端子をそれぞれ測定対象の両端に接続します。オートレンジです。

### 別売り外付け部品

- 表面実装用タクトスイッチ [THAU13-AB-R](https://akizukidenshi.com/catalog/g/g114889/)

  スイッチを取り付けない場合、下写真のようにCOM端子とスルーホール部分を接触させることでスイッチとして動作させることができます。

  <br>

- 100kΩ半固定ボリューム（音量調整用、固定抵抗でも可）、圧電スピーカー（[PT33-130740HPR](https://akizukidenshi.com/catalog/g/g131072/)等）

  導通チェッカーとして動作させる場合、ブザー音を鳴らすために取り付けます。
  
- 基板取付用DCジャック（[MJ-179P](https://akizukidenshi.com/catalog/g/g109408/)等）

  USBコネクター以外から電源を供給する場合に取り付けます。

※ 長期使用に伴い、ディスプレイの表示が薄くなったり表示が焼き付いたりする可能性があります。交換品として、一般的な0.96インチ単色OLED（制御チップSSD1306）が使用可能です。

### 機能設定

導通チェックの抵抗値設定やキャリブレーションを行うことができます。右側のスイッチは、上からA、B、Cとしています。スイッチCを長押しすると設定モードが切り替わります。

※ 出荷時に1回、キャリブレーションを行ってあります。

- 通常モード

  通常の電圧・抵抗測定です。

  <br>

  - A 短押し：電圧計オン／オフ
  - B 短押し：抵抗計オン／オフ
  - C 短押し：ブザー音オン／オフ
  - A 長押し：設定保存実行
  - C 長押し：モード切替

- 導通チェック設定モード

  ブザー音を鳴らす抵抗値の閾値と、その閾値を下回ったときに鳴らすブザー音の周波数を設定できます。複数の条件に当てはまった場合、順番は関係なく抵抗値が少ない方が優先されます。初期値は、全て100Ω、1000Hzに設定されています。

  ※ ブザー音の周波数は目安です。圧電スピーカーの種類によっては、大幅に違う周波数の音が聞こえる場合があります。

  <br>
  
  - A 短押し：値を増加／実行
  - B 短押し：値を減少
  - C 短押し：カーソル移動
  - A 長押し：値を大きく増加
  - B 長押し：値を大きく減少
  - C 長押し：モード切替
  
- ADCキャリブレーションモード

  アナログ・デジタルコンバーター（ADC）の誤差を補正します。＜0V＞ではCOM端子とV・Ω端子をショートさせ、補正のオフセット値を算出します。もう一方では任意の電圧（1～20V）の基準電圧源を設定・接続し、補正の傾きを算出します。

  <br>

  - A 短押し：値を増加／実行
  - B 短押し：値を減少
  - C 短押し：カーソル移動
  - C 長押し：モード切替
  
- 抵抗キャリブレーションモード

  抵抗測定の誤差を補正します。基準抵抗を順番に接続し、補正の傾きとオフセット値を算出します（10Ω抵抗を接続し実行、200Ω抵抗を接続し実行……と繰り返す）。カーソルは自動で移動するので、やり直す場合は電源を入れ直してください。

  <br>

  - A 短押し：実行
  - C 長押し：モード切替

### 資料

- [Easy Tester 製作に関する記事](https://kanengomibako.github.io/pages/00383_EasyTester.html)

| 主な仕様<br>（メイン基板モジュール） |  |
| - | - |
| 測定可能電圧 | 0.2 ～ 20V（精度：1％ + 1 mV） |
| 測定可能抵抗値 | 0 ～ 2.2MΩ（精度：1％ + 1 Ω） |
| 電源電圧 | 4.5 ～ 20V |
| 消費電流 | 待機時 8 mA（最大20mA） |
| 外形寸法 | 幅 45 mm × 奥行 35 mm × 高さ 5 mm |
| 質量 | 約 6 g |

Parts:
C1, C2, C4, C5: 1u; C_0603_1608Metric; MPN C15849
C3: 220p; C_0603_1608Metric; MPN C1603
C6: 100u; C_1206_3216Metric; MPN C15008
C8: X; C_0603_1608Metric
D1, D2, D3, D4: 1N4148WS; my_D_SOD-323; MPN C2128
D5: LED; LED_0603_1608Metric; MPN C2286
J1: 5V; PinHeader_1x01_P2.54mm_Vertical
J2: GND; PinHeader_1x01_P2.54mm_Vertical
J3: VOLT/OHM; tester_pad2
J4: COM; tester_pad3
J6: 0.96"_OLED_Display_Module; OLED_Display_0.96inch
J7: TYPE-C-31-M-12; USB_C_TYPE-C-31-M-12; MPN C165948
J8: DC_IN; my_DC_Jack
Q1: AO3401A; SOT-23; MPN C15127
R0: 0R; R_0603_1608Metric; MPN C21189
R1, R9, R17: 200R; R_0603_1608Metric; MPN C8218
R2, R6, R8, R10: 2.2k; R_0603_1608Metric; MPN C4190
R3: 22k; R_0603_1608Metric; MPN C31850
R4: 220k; R_0603_1608Metric; MPN C22961
R5: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7: 27k; R_0603_1608Metric; MPN C22967
R11: 4.7M; R_0603_1608Metric; MPN C23163
R12: 2.2M; R_0603_1608Metric; MPN C22938
R13, R14: 1.5M; R_0603_1608Metric; MPN C4172
R15: 100k; R_0603_1608Metric; MPN C25803
R16, R18: 10k; R_0603_1608Metric; MPN C25804
R20, R21, R22, R23: 5.1k; R_0402_1005Metric; MPN C25905
SP1: Speaker; Buzzer_12x9.5RM7.6
SW0, SW1, SW2: SW; THAF01-NC-R
TP1: SWIO; PinHeader_1x01_P2.54mm_Vertical
TP2: 3.3V; my_SmallestPad_0-6mmDrill
TP3: PC7; my_SmallestPad_0-6mmDrill
TP4: NRST; my_SmallestPad_0-6mmDrill
TP5: PD3; my_SmallestPad_0-6mmDrill
TP6: PD0; my_SmallestPad_0-6mmDrill
TP7: V+; my_SmallestPad_0-6mmDrill
TP8: V-; my_SmallestPad_0-6mmDrill
TP9, TP10: GND; my_SmallestPad_0-6mmDrill
TP12: PD6; my_SmallestPad_0-6mmDrill
U1: CH32V006F8U6; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm; MPN C42431288
U2: HT7533-1; SOT-89-3; MPN C14289

Connections:
+3.3V: C1.1, C5.2, C6.2, J6.2, R6.1, R18.2, R20.2, R21.2, TP2.1, U1.6 (VDD), U2.3 (VOUT)
/ADC: R13.2, R14.2, U1.19 (PD5)
/OPA+: C2.1, R6.2, R7.1, U1.3 (PA2)
/OPA-: C3.1, R10.2, U1.2 (PA1)
/OPA_Out: C3.2, R9.2, U1.18 (PD4)
/R0: R0.2, U1.7 (PC0)
/R1: R1.2, U1.10 (PC3)
/R2: R2.2, U1.11 (PC4)
/R3: R3.2, U1.12 (PC5)
/R4: R4.2, U1.13 (PC6)
/SCL: J6.3, R21.1, U1.9 (PC2)
/SDA: J6.4, R20.1, U1.8 (PC1)
GND: C1.2, C2.2, C4.1, C5.1, C6.1, C8.2, D5.1 (K), J2.1, J4.1, J6.1, J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), J7.S1 (SHIELD), J8.1, R8.2, R15.1, R22.1, R23.1, SP1.2, SW0.2, SW1.2, SW2.2, TP8.1, TP9.1, TP10.1, U1.4 (VSS), U1.21 (VSS), U2.1 (GND)
unnamed: C8.1, R11.2, R12.1
unnamed: D1.2 (A), J8.2, TP7.1
unnamed: C4.2, D1.1 (K), D2.1 (K), D3.1 (K), U2.2 (VIN)
unnamed: D2.2 (A), J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS)
unnamed: D3.2 (A), J1.1
unnamed: D4.2 (A), Q1.3 (D)
unnamed: D4.1 (K), J3.1, R11.1
unnamed: D5.2 (A), R16.1
unnamed: J7.A5 (CC1), R22.2
unnamed: J7.B5 (CC2), R23.2
unnamed: Q1.1 (G), R9.1
unnamed: Q1.2 (S), R0.1, R1.1, R2.1, R3.1, R4.1, R10.1
unnamed: R5.1, R5.2, SP1.1
unnamed: R7.2, R8.1
unnamed: R12.2, R13.1
unnamed: R14.1, R15.2
unnamed: R5.3, R17.1
unnamed: SW2.1, TP3.1, U1.14 (PC7)
unnamed: SW0.1, TP6.1, U1.5 (PD0)
unnamed: TP1.1, U1.15 (PD1)
unnamed: R17.2, U1.16 (PD2)
unnamed: SW1.1, TP5.1, U1.17 (PD3)
unnamed: R16.2, TP12.1, U1.20 (PD6)
unnamed: R18.1, TP4.1, U1.1 (PD7)

Notes on the sheet:
Easy Tester
Rev.E Dec. 2025 github.com/kanengomibako

Board: 2 copper layers, 45.0 x 35.0 mm, 65 parts (8 on the bottom side), 37 nets.

Other parts of the board:
*: M; MountingHole_3.2mm_M3
*#2, *#3, *#4, *#5: M; MountingHole_3.2mm_M3

## KiCad design 9VIsolator/9Visolator_RevF.kicad_pcb

File 9VIsolator/README.md:

## 9V Isolator

<br>

9V電源入力から、アイソレートされた9V電源を出力するモジュールです。グラウンドの分離や負電源生成に使用できます。リニアレギュレータを搭載し、ノイズを低減しています。

### 配線方法

- IN+ → 電源入力 +
- IN- → 電源入力 -（グラウンド）
- OUT+ → 電源出力 +
- OUT- → 電源出力 -

### 使用例

<br>

### 注意事項

- 出力電流は、70mAを超えて使用しないでください。
- 複数モジュールを並列使用しないでください。電流が偏り故障の原因となります。
- 入力側の電源は、充分余裕のある電流出力が可能なものを接続してください。
- 発熱があるため、熱傷にご注意ください。

出力電流に対する入力側の電流、本体の最高温度は以下の通りです（気温20℃付近で測定）。

| 出力側電流 | 入力側電流 | 温度 |
| ---------- | ---------- | ---- |
| 0 mA       | 17 mA      | 32℃  |
| 10 mA      | 33 mA      | 34℃  |
| 20 mA      | 46 mA      | 36℃  |
| 30 mA      | 60 mA      | 38℃  |
| 40 mA      | 74 mA      | 40℃  |
| 50 mA      | 88 mA      | 42℃  |
| 60 mA      | 102 mA     | 44℃  |
| 70 mA      | 118 mA     | 46℃  |

### 資料
- [9V Isolator 製作に関する記事](https://kanengomibako.github.io/pages/00374_9Visolator.html)
- [旧バージョン（Rev.E）の説明書](README_RevE.md)

| 主な仕様 |  |
| - | - |
| 入力電圧 | 8.7V ～ 10.4V |
| 出力電圧 | 9.2V ～ 9.3V |
| 最大出力電流 | 70mA（入力側消費電流 118mA） |
| 外形寸法 | 幅 25.5 mm × 奥行 11.2 mm × 高さ 12.5 mm |
| 質量 | 約 2.3 g |

Parts:
C1, C2: 2.2u; C_0805_2012Metric; LCSC C377773
C3: 47u; C_1206_3216Metric; LCSC C96123
C4: 22u; CP_EIA-3528-15_AVX-H; LCSC C7199
D1, D2: SM4007; D_SOD-123F; LCSC C64898
J1: IN; my_conn
J2: OUT; my_conn
R1: 270R; R_0603_1608Metric; LCSC C22966
R2: 1.5k; R_0603_1608Metric; LCSC C22843
R3: 4.7k; R_0603_1608Metric; LCSC C23162
R4: 220R; R_0603_1608Metric; LCSC C22962
R5: 3.3k; R_0603_1608Metric; LCSC C22978
U1: B0912S-1WR3; Converter_DCDC_Murata_MEE1SxxxxSC_THT
U2: LD1117AG-AD-AB3-A; SOT-89-3; LCSC C80540

Connections:
GND: C2.1, C3.1, C4.2, J2.2, R3.2, R4.2, R5.2, U1.3 (-Vout)
GND_IN: C1.1, J1.2, U1.1 (-Vin)
unnamed: D1.2 (A), J1.1
unnamed: C1.2, D1.1 (K), U1.2 (+Vin)
unnamed: C4.1, D2.2 (A), J2.1, R1.1, U2.2 (VO)
unnamed: C2.2, D2.1 (K), R5.1, U1.4 (+Vout), U2.3 (VI)
unnamed: R2.2, R3.1, R4.1
unnamed: C3.2, R1.2, R2.1, U2.1 (ADJ)

Notes on the sheet:
9V Isolator
Rev.F Jan. 2026 github.com/kanengomibako

Board: 2 copper layers, 25.5 x 11.0 mm, 15 parts (0 on the bottom side), 8 nets.

## KiCad design 10VBlocker/10VBlocker_RevB.kicad_pcb

File 10VBlocker/README.md:

# 10V Blocker

<br>10V以上の電圧が入力されると、電源供給を遮断するモジュールです。

### 配線方法

- IN → 電源入力 +
- 上側中央のパッド → 電源入出力 -（グラウンド）
- OUT → 電源出力 +

基板下側のパッドはどこにも接続されていません。マル信無線電機 DCジャック MJ-40Aに直付けする場合、電池の接続が可能です。

### 注意事項

- 新品の電池は電圧が10V以上の場合があり、本モジュールにより電源が遮断される可能性があります。
- 電源の遮断が不十分となる場合があるため、消費電流0.1mA未満の機器には使用しないでください。

### 資料

- [10V Blocker 製作に関する記事](https://kanengomibako.github.io/pages/00379_10VBlocker.html)

| 主な仕様     |                                     |
| ------------ | ----------------------------------- |
| 最大入力電圧 | 30V                                 |
| 遮断電圧     | 10.0V ～ 10.3V                      |
| 直列抵抗     | 0.04Ω                               |
| 消費電流     | 0.7mA                               |
| 最大出力電流 | 1A                                  |
| 必要出力電流 | 0.1mA以上                           |
| 外形寸法     | 幅 12 mm × 奥行 10 mm × 高さ 2.5 mm |
| 質量         | 約 0.4 g                            |

Parts:
C101: 100n; C_0603_1608Metric; LCSC C14663
D101: SM4007; D_SOD-123F; LCSC C64898
J101: DC_IN; MJ-40A
J102: OUT; PinHeader_1x01_P2.54mm_Vertical
R101: 180k; R_0603_1608Metric; LCSC C22827
R102: 22k; R_0603_1608Metric; LCSC C31850
R103: 33k; R_0603_1608Metric; LCSC C4216
U101: MX25947ES; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.62x3.51mm; LCSC C5875698

Connections:
GND: C101.2, D101.2 (A), J101.1, R103.2, U101.9 (Pin_8)
unnamed: C101.1, D101.1 (K), J101.2, R101.1, U101.7, U101.8
unnamed: J102.1, U101.1, U101.2
unnamed: R102.2, R103.1, U101.4
unnamed: R101.2, R102.1, U101.6

Notes on the sheet:
V_{OVPR} = 1.42V (Actual measured value)
電源出力-
10V Blocker
電源出力+
電源入力-
Rev.B Dec. 2025 github.com/kanengomibako
電源入力+

Board: 2 copper layers, 12.0 x 9.5 mm, 8 parts (0 on the bottom side), 5 nets.

## KiCad design 9VIsolator/9Visolator_RevE.kicad_pcb

Parts:
C1, C2, C3, C6: 2.2u; C_0805_2012Metric; MPN C377773
C4, C5: 22u; C_0805_2012Metric; MPN C45783
D1, D2: 1N5819WS; my_D_SOD-323; MPN C191023
J1: IN; my_conn
J2: OUT; my_conn
R1: 150R; R_0603_1608Metric; MPN C22808
R2: 1k; R_0805_2012Metric; MPN C17513
R3: 20k; R_0603_1608Metric; MPN C4184
U1: B0912S-1WR3; Converter_DCDC_Murata_MEE1SxxxxSC_THT; MPN C19272674
U2: LD1117AG-AD-AB3-A; SOT-89-3-rotate; MPN C80540

Connections:
GND: C2.1, C3.1, C4.1, C5.1, C6.1, J2.2, R2.2, R3.2, U1.3 (-Vout)
GND_IN: C1.1, J1.2, U1.1 (-Vin)
unnamed: D1.2 (A), J1.1
unnamed: C1.2, D1.1 (K), U1.2 (+Vin)
unnamed: C2.2, D2.2 (A), U1.4 (+Vout)
unnamed: C3.2, D2.1 (K), U2.3 (VI)
unnamed: C6.2, J2.1, R1.1, U2.2 (VO)
unnamed: C4.2, C5.2, R1.2, R2.1, R3.1, U2.1 (ADJ)

Notes on the sheet:
9V Isolator
Rev.E Oct. 2025 github.com/kanengomibako

Board: 2 copper layers, 25.5 x 11.0 mm, 15 parts (0 on the bottom side), 8 nets.

## KiCad design DropInTapPT2399/KiCad/DropInTapPT2399.kicad_pcb

File DropInTapPT2399/README.md:

# DropInTap PT2399

<br>

ディレイIC PT2399にタップテンポコントロールを追加したモジュールです。DIPパッケージのPT2399をそのまま置き換えることができます。

[販売ページはこちら](https://kanengomibako.booth.pm/items/7034304)

### 配線方法

<br>

- DTime → ディレイタイムポット（50kΩ Bカーブ）

- TapDiv → スイッチ（ON-OFF-ON タイプ）

- LED → LEDと電流制限抵抗

  設定したテンポに合わせて5Vが出力されます。電流制限抵抗の抵抗値は470Ω以上を推奨します。LEDの点滅はノイズ源となるので、エフェクターの入力部を近づけないよう取り付け位置や配線に注意してください。

- TapSw → スイッチ

  モーメンタリー（モメンタリ）のスイッチを使用します。SPST（単極単投、1回路1接点）のものが入手しやすいです。

基板上の5VおよびGNDパッドは、それぞれ電源およびグラウンドに接続されています。配線時にはこれらのパッドを利用できます。その他の四角形のパッドは、通常のPT2399と同様に扱ってください。なお、基板上にPT2399が実装されている側が上側（トップ面）です。

※ 基板上のピン番号6に相当するパッドはどこにも接続されていません。ディレイタイムの設定には、DTimeパッドのみ使用してください。

### タップテンポ入力
TapSwパッドに接続されたスイッチ（タップスイッチ）を複数回押下（タップ）すると、タップの間隔に応じたテンポが入力されます。タップは直近5回分が記録され、タップ間隔の平均値によりテンポが決まります。TapDivパッドに接続されたスイッチ（DIVスイッチ）の接続状態により、テンポを基準としたディレイタイムが1/2、3/4、または1倍に分割され設定されます。

| DIVスイッチ接続    | 割合  | 拍                                           |
| ------------------ | ----- | -------------------------------------------- |
| 電源（5V）         | 1 / 2 |       |
| オープン（未接続） | 3 / 4 |  |
| グラウンド（0V）   | 1 / 1 |         |

前回のタップから1秒以上間隔があいてタップした場合、そのタップは1回目としてカウントされます。タップを1回だけ行った場合、LEDの点滅タイミングだけがリセットされ、前回入力していたテンポがそのまま残ります。

### ディレイタイムポット

起動時、およびDTimeパッドに接続されたポット（ディレイタイムポット）を動かしたときはタップテンポ入力が解除され、ディレイタイムポットによりディレイタイムが設定される状態となります。ディレイタイムポットの抵抗値が50kΩより小さい場合は最大ディレイタイムが少なくなりますので、抵抗値のばらつきにご注意ください。

### LED点滅設定
タップテンポ入力が有効な場合、テンポに合わせて常にLEDが点滅します。ディレイタイムポットでディレイタイムを設定している場合にも、ディレイタイムに応じてLEDを点滅させる機能があります（初期設定は無効）。下記の操作で有効・無効の切り替えができます。

1. タップスイッチを押しながら電源を入れ、そのままタップスイッチを押し続けます。
2. 3秒経過するとLEDが点灯するので、タップスイッチを離します。
3. 設定が変更、保存され、LEDが2回点滅します。

### キャリブレーション

部品の誤差や個体差により入力したテンポとディレイタイムにずれが生じるため、出荷時にキャリブレーションによる補正を行っています（電源電圧5V、温度24℃付近）。基本的に再度のキャリブレーションは不要ですが、より精度を確実にしたい場合、下記の操作によりキャリブレーションを行うことができます。

1. **キャリブレーション中は大きな音が発生するため、必ずエフェクトオフ、ディレイ音を最小音量にします。**
2. タップスイッチを押しながら電源を入れ、そのままタップスイッチを押し続けます。
3. 3秒経過するとLEDが点灯します。さらに3秒経過しLEDの明るさが弱くなったら、タップスイッチを離します。
4. キャリブレーションが実行されLEDが点滅します。LEDの点滅はだんだん速くなります。この間、タップスイッチを操作しないでください。
5. 約30秒でキャリブレーションが終了し、校正値が保存され通常動作になります。LEDが点灯し続けている場合、何らかのエラーが発生しているので電源を入れ直してください。

### 資料
- [DropInTap PT2399 製作に関する記事](https://kanengomibako.github.io/pages/00365_DropInTapPT2399.html)

| 主な仕様 |  |
| - | - |
| ディレイタイム設定範囲 | 55 ミリ秒 ～ 700 ミリ秒 |
| タップテンポ精度 | ±2 ミリ秒未満（電源 5 V、温度 24 ℃） |
| 電源電圧 | 5 V（4.6 V ～ 5.4 V で使用可能） |
| 消費電流 | 30 mA |
| 外形寸法 | 幅 10.3 mm × 奥行 20.5 mm × 高さ 3.8 mm |
| 質量 | 約 0.7 g |

Board: 4 copper layers, 10.1 x 20.2 mm, 26 parts (18 on the bottom side), 27 nets.

Parts:
C1, C2, C3, C5: 100n; C_0402_1005Metric
J1: LED; my_WirePad_0-8mmDrill
J2: TapSw; my_WirePad_0-8mmDrill
J3: 5V; my_WirePad_0-8mmDrill
J4, J99: GND; my_WirePad_0-8mmDrill
J5: TapDiv; my_WirePad_0-8mmDrill
J6: DTime; my_WirePad_0-8mmDrill
J7: PT2399_CONN; my_DIP-16_ex
Q1: MMBT3904; SOT-23_rotate
R1, R2, R3: 10k; R_0402_1005Metric
R4: 47k; R_0402_1005Metric
R5, R6, R7, R8: 33k; R_0402_1005Metric
R9: 1.5k; R_0402_1005Metric
TP1: SWIO; my_WirePad_1mmDrill
U1: CH32V003F4U6; QFN-20-1EP_3x3mm_rotate
U2: LMV321; my_SOT-23-5_rotate
U3: PT2399; my_SOP-16_SmallPad

Connections:
+5V: C1.1, C5.1, J3.1, J7.1, R2.1, R4.2, U1.6 (VDD), U2.5 (V+), U3.1 (VCC)
GND: C1.2, C2.2, C3.2, C5.2, J4.1, J7.3, J7.4, J99.1, R3.2, R8.2, R9.1, U1.4 (VSS), U1.21 (VSS), U2.2 (V-), U3.3 (AGND), U3.4 (DGND)
unnamed: C2.1, R5.2, R6.1
unnamed: J1.1, U1.3 (PA2)
unnamed: J2.1, U1.2 (PA1)
unnamed: J5.1, R2.2, R3.1, U1.19 (PD5)
unnamed: J6.1, R4.1, U1.20 (PD6)
unnamed: J7.2, U3.2 (REF)
unnamed: J7.7, U3.7 (CC1)
unnamed: J7.8, U3.8 (CC0)
unnamed: J7.9, U3.9 (OP1-OUT)
unnamed: J7.10, U3.10 (OP1-IN)
unnamed: J7.11, U3.11 (OP2-IN)
unnamed: J7.13, U3.13 (LPF2-IN)
unnamed: J7.14, U3.14 (LPF2-OUT)
unnamed: J7.15, U3.15 (LPF1-OUT)
unnamed: Q1.1 (B), U2.4
unnamed: Q1.2 (E), R9.2, U2.3 (-)
unnamed: R7.2, R8.1
unnamed: R1.2, U1.13 (PC6)
unnamed: TP1.1, U1.15 (PD1)
unnamed: R5.1, U1.16 (PD2)
unnamed: C3.1, R6.2, R7.1, U2.1 (+)
PT2399_5: J7.5, U1.18 (PD4), U3.5 (CLK_O)
PT2399_6: Q1.3 (C), U3.6 (VCO)
PT2399_12: J7.12, U1.17 (PD3), U3.12 (OP2-OUT)
PT2399_16: J7.16, R1.1, U3.16 (LPF1-IN)

## Commit log

2025-07-05 Move folders
2025-10-22 Add 9V Isolator
2025-12-25 Add Overvoltage Protector
2026-01-27 Rename Overvoltage Protector
2026-02-13 Add README
2026-02-14 Update KiCad data
2026-03-30 Add Easy Tester
2026-04-03 Update True Bypass Relay Module THD
2026-04-03 Add Buffered Bypass Module THD
2026-05-06 Update README, Src
